Commit message: Fixed joint vector bug.

File: body0.urdf (robot description, URDF)
Before this commit: robot robot, 3 links, 2 joints
Joints:
- joint Torso_BackLeg: axis [0 1 0] -> 1 0 0
- joint Torso_FrontLeg: axis [-1 0 0] -> 1 0 0
